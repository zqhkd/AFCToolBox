// 根据AFC5Abt2.03.240214调试后240221给出建议，添加L161: Send_buffer[pHeader++] = 5;
#include "SerialProto.h"

int pRecvNum;

unsigned char getCmdType()
{
	return Recv_buffer[0];
}

unsigned char getMsgLen()
{
	pRecvNum = Recv_buffer[1];
	return pRecvNum;
}

unsigned char setMsgLen()
{
	Send_buffer[1] = pSendNum + 5;
	return (pSendNum + 5);
}

unsigned char getInportNum()
{
	return Recv_buffer[2];
}

unsigned char getOutportNum()
{
	return Recv_buffer[3];
}

void setInportNum()
{
	Send_buffer[2] = InportCnt;
}

void setOutportNum()
{
	Send_buffer[3] = OutportCnt;
}

int AddDataToBlkSendBuffer(unsigned short blkInstName, int elem, float* src, unsigned char* dstBuffer)
{
	int pHeader = 0;

	unsigned char low8blkInstName = (unsigned char)(blkInstName & 0xff);
	unsigned char high8blkInstName = (unsigned char)(blkInstName >> 8);
	dstBuffer[pHeader++] = high8blkInstName;
	dstBuffer[pHeader++] = low8blkInstName;

	for (size_t i = 0; i < elem; i++)
	{
		dstBuffer[pHeader++] = ((unsigned char*)(&src[i]))[0];
		dstBuffer[pHeader++] = ((unsigned char*)(&src[i]))[1];
		dstBuffer[pHeader++] = ((unsigned char*)(&src[i]))[2];
		dstBuffer[pHeader++] = ((unsigned char*)(&src[i]))[3];
	}

	return pHeader;
}

void AddDataToModelSendBuffer(int elem, unsigned char* srcBuffer)
{
	
	int pHeader = 0;

	/* send buffer??,????*/
	if (Send_buffer[pHeader] != START_CMD && Send_buffer[pHeader] != NOTIFY_DATA)
	{
		Send_buffer[pHeader++] = NOTIFY_DATA;/* ???8bit,0x5F??????,0x6D?????? */
		Send_buffer[pHeader++] = 0;/* ??? */
		Send_buffer[pHeader++] = InportCnt;/* ??blk?? */
		Send_buffer[pHeader++] = OutportCnt;/* ??blk?? */
	}
	else
	{
	/*	for (size_t i = 0; i < MAX_LENGTH; i++)
		{
			if (Send_buffer[i] == END_FLAG)
			{
				pHeader = i;
				break;
			}
		}*/
		pHeader = pSendNum + 4;
	}

	for (size_t i = 0; i < elem; i++)
	{
		Send_buffer[pHeader++] = srcBuffer[i];
	}

	Send_buffer[pHeader] = END_FLAG;
	pSendNum += elem;
}

void GetDataFromRecvBufferByInstname(unsigned short blkInstName, int elem, float* dstBuffer)
{
	int pos = 0;
	union IU32 data;

	unsigned char low8blkInstName = (unsigned char)(blkInstName & 0xff);
	unsigned char high8blkInstName = (unsigned char)(blkInstName >> 8);

	for (size_t i = 0; i < MAX_LENGTH; i++)
	{
		if (Recv_buffer[i] == low8blkInstName)
		{
			if (Recv_buffer[i - 1] == high8blkInstName)
			{
				pos = i + 1;
				break;
			}
			
		}
	}

	size_t iHeader = 0;
	for (size_t i = 0; i < elem; i++)
	{
		size_t j;
		for (j = 0; j < 4; j++)
		{
			data.c[j] = Recv_buffer[pos + j + i * 4];
		}

		dstBuffer[iHeader++] = data.f32;
	}

}

void SetDataByInstname(unsigned short blkInstName, int elem, float* srcBuffer)
{
	unsigned char* dstCharBuf = (unsigned char*)malloc((elem * 4 + 2) * sizeof(unsigned char));

	int num = AddDataToBlkSendBuffer(blkInstName, elem, srcBuffer, dstCharBuf);
	AddDataToModelSendBuffer(num, dstCharBuf);
	free(dstCharBuf);
	dstCharBuf = NULL;
}

void AddStartCmdToSendBuffer()
{
	int pHeader = 0;

	memset(Send_buffer, 0, MAX_LENGTH);

	Send_buffer[pHeader++] = START_CMD;
	Send_buffer[pHeader++] = END_FLAG;

}

void AddNullToSendBuffer()
{
	int pHeader = 0;

	memset(Send_buffer, 0, MAX_LENGTH);

	Send_buffer[pHeader++] = NOTIFY_DATA;
   	Send_buffer[pHeader++] = 5;
	Send_buffer[pHeader++] = InportCnt;
	Send_buffer[pHeader++] = OutportCnt;
	Send_buffer[pHeader++] = END_FLAG;

}
